include u-boot-hostmobility.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=a2c678cfd4a4d97135585cad908541c6"

SRCREV = "${AUTOREV}"
SRCBRANCH = "mx4-bsp-2.0.x-IMX7"
PV = "v${SRCBRANCH}+git${SRCPV}"
